Commit message: second commit

File: Panda/panda_.urdf (robot description, URDF)
Before this commit: robot panda, 11 links, 10 joints
Joints:
- joint panda_calibration: origin xyz=0 -0.15 0 rpy=-1.57079632679 0 3.141592 -> xyz=0 -0.2 0 rpy=0 0 0
